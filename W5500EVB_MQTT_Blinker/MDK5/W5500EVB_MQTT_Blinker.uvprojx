# Keil uVision project W5500EVB_MQTT_Blinker.uvprojx, settings and files
target W5500EVB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: W5500EVB_MQTT_Blinker +hex
  AfterMake: fromelf.exe #L --vhx --8x1 --output *.hex;fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\STM32XX_Driver\inc;..\System;..\User\Driver;..\User\Application;..\User\MQTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STM32XX_Driver
    ../STM32XX_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c misc.c
  group System
    ../System/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group Application
    ../User/Application/: config.h main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h types.h
  group Driver
    ../User/Driver/: device.c device.h socket.c socket.h spi2.c spi2.h ult.c ult.h usart.c usart.h w5500.c w5500.h tcpc.c cjson_test.c cjson_test.h
  group MQTT
    ../User/MQTT/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c transport.c linkplatform.c linkplatform.h cJSON.c
